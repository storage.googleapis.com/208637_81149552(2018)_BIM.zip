Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-21T00:09:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 21 00:09:30 2025 * Host: DESKTOP-6R5H9TJ * Database: C:\Users\FTLNinja\AppData\Local\Temp\a52087a9-c82e-4df3-a941-e1f902ed82a5\2d1b925e-38c2-4393-8fb8-cb2ff020d5c3\ifc * Database version: 5507 * Database creation date: Wed May 21 00:09:29 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 21 00:09:29 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 21 00:09:29 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 81149552(2025):82603067 Cover part for bath and shower faucet, 81149552(2025):82603067 Cover part for bath and shower faucet:303587
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMStone; BIMObjectName: 82603067(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: PA-IX 38594/IDC; Approval DVGW: DW-6506CS0196; EAN Number: 4057304017384; EN Standard: EN 817; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 204 x 186 x 174; UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/82603067; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/82603067; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/82603067; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.hansa.com/EPD/82603067; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/166416_82603067_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/82603067
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/82603067; 3D View: https://static.hansa.com/3D/82603067; Catalog Drawing URL: http://static.hansa.com/catdrw/82603067; Category B2C: Bathtub & Shower; Dimension Drawing URL: http://static.hansa.com/dimdrw/82603067; FDV Document URL: http://www.hansa.com/datasheet/82603067/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/82603067; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/82603067; Interactive AR View URL: https://static.hansa.com/AR/82603067; Long Marketing: The HANSAVANTIS is the perfect fit for any bathroom, with a proven expert quality you can rely on, no matter your specific needs. Durable and long-lasting in both design and service life, this faucet brings you joy and confidence for years to come. Functional considerations and a dedicated level of detail offer a new user experience. Elegant and functional designed diverter Vacuum breaker High quality Sleek design Double outlet diverter Made in Europe Shower and bath faucet with maximum comfort; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/82603067; Model: 82603067 Cover part for bath and shower faucet; Name_en: 82603067 Cover part for bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 82603067; Product Family: HANSAVANTIS; Product Image URL: http://static.hansa.com/image/82603067; Product URL: http://static.hansa.com/82603067; Replacement to: 82603077; Spare-Part Information URL: http://static.hansa.com/sp/82603067; Technical DataSheet URL: http://www.hansa.com/datasheet/82603067/en; Type Name: 82603067 Cover part for bath and shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Concealed Parts: Rosette plate frame;Round rosette;BLUECLICK for an easy, screwless trim plate installation;BLUETUNE alignment after installation of +/- 3,5º;Fastening of the function unit with screws;Function unit; Diverter: Turn operated diverter; Flow Rate At 300kPa: 0.3 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control;Vacuum breaker; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 81149552(2025); Features: Trim Kit;Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 82603067; Name: 82603067 Cover part for bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x75x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 82603067; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 82603067 Cover part for bath and shower faucet; Category: Plumbing Fixtures
Type - Pset_ValveTypeCommon - FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 82603067 Cover part for bath and shower faucet; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - Type: 0 mm
Dimensions - Area: 0.0561671 m2; Volume: 0.00231569 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 81149552(2025): 82603067 Cover part for bath and shower faucet; Family and Type: 81149552(2025): 82603067 Cover part for bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 81149552(2025): 82603067 Cover part for bath and shower faucet; Type Id: 81149552(2025): 82603067 Cover part for bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
